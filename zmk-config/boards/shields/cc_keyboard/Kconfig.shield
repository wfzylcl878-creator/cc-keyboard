## zmk-config/boards/shields/cc_keyboard/Kconfig.shield
```kconfig
# SPDX-License-Identifier: MIT

config SHIELD_CC_KEYBOARD
	def_bool $(shields_list_contains,cc_keyboard)
```
